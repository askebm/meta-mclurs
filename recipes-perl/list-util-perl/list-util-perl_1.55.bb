LICENSE = "Unknown"
SRC_URI = "https://cpan.metacpan.org/authors/id/P/PE/PEVANS/Scalar-List-Utils-1.55.tar.gz"
SRC_URI[md5sum] = "7988f5111e33ba47e175cf3e86b0d93f"
SRC_URI[sha256sum] = "4d2bdc1c72a7bc4d69d6a5cc85bc7566497c3b183c6175b832784329d58feb4b"
S = "${WORKDIR}/Scalar-List-Utils-1.55/"
inherit cpan
DEPENDS = " \
"
RDEPENDS_${PN} = " \
"
