LICENSE = "Unknown"
SRC_URI = "https://cpan.metacpan.org/authors/id/S/SH/SHAY/perl-5.30.2.tar.gz"
SRC_URI[md5sum] = "1fffdce56f2b307608e3c7497f66daad"
SRC_URI[sha256sum] = "66db7df8a91979eb576fac91743644da878244cf8ee152f02cd6f5cd7a731689"
S = "${WORKDIR}/perl-5.30.2/"
inherit cpan_build
DEPENDS = " \
"
RDEPENDS_${PN} = " \
"
