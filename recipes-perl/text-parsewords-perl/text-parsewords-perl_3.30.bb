LICENSE = "Unknown"
SRC_URI = "https://cpan.metacpan.org/authors/id/C/CH/CHORNY/Text-ParseWords-3.30.tar.gz"
SRC_URI[md5sum] = "9e98d7ba9a2eecd49c21b37d5f04a7a7"
SRC_URI[sha256sum] = "85e0238179dd43997e58c66bd51611182bc7d533505029a2db0d3232edaff5e8"
S = "${WORKDIR}/Text-ParseWords-3.30"
inherit cpan
DEPENDS = " \
"
RDEPENDS_${PN} = " \
"
