LICENSE = "Unknown"
SRC_URI = "https://cpan.metacpan.org/authors/id/A/AT/ATOOMIC/Devel-PPPort-3.58.tar.gz"
SRC_URI[md5sum] = "20bf4875bf1a0d0ec5696a00e5ed0929"
SRC_URI[sha256sum] = "531ff79f9e74962df2dba7b2e526b8a5208cfb6bcdc01d85732fda8c1fde0c00"
S = "${WORKDIR}/Devel-PPPort-3.58/"
inherit cpan
DEPENDS = " \
"
RDEPENDS_${PN} = " \
"
