LICENSE = "Unknown"
SRC_URI = "https://cpan.metacpan.org/authors/id/J/JP/JPEACOCK/version-0.9924.tar.gz"
SRC_URI[md5sum] = "8d252fa8530b53d4baefbb89c5c60929"
SRC_URI[sha256sum] = "81e4485ff3faf9b7813584d57b557f4b34e73b6c2eb696394f6deefacf5ca65b"
S = "${WORKDIR}/version-0.9924/"
inherit cpan
DEPENDS = " \
"
RDEPENDS_${PN} = " \
"
