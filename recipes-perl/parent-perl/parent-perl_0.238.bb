LICENSE = "Unknown"
SRC_URI = "https://cpan.metacpan.org/authors/id/C/CO/CORION/parent-0.238.tar.gz"
SRC_URI[md5sum] = "941ab8fb242372c09a7d605e8d56f2ac"
SRC_URI[sha256sum] = "38f58fdef3e28a194c9c8d0dc5d02672faf93c069f40c5bcb1fabeadbbc4d2d1"
S = "${WORKDIR}/parent-0.238/"
inherit cpan
DEPENDS = " \
"
RDEPENDS_${PN} = " \
"
